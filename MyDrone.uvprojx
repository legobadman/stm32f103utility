# Keil uVision project MyDrone.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: drone +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\Lib\inc;.\Lib\src;.\User;.\Startup;.\Basic\delay;.\Basic\sys;.\Basic\i2c;.\Hardware\MPU6050;.\Basic\usart;.\Basic\dmp;.\Basic\fbm320;.\Basic\NRF24L01;.\Basic\spi;.\Basic\bmp280;.\Hardware\NRF24L01;.\Hardware\BMP280;.\Hardware\HMC5883L;C:\Keil_v5\ARM\ARMCC\include;.\Hardware\BT;.\Hardware\FBM320;.\Basic\adc;.\Hardware\Motor;.\Basic\pwm;.\Hardware\MPU6050\DMP;.\Hardware\MPU6050\EXTI;.\Hardware\DMP;.\Hardware;.\Control
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_pwr.c stm32f10x_i2c.c stm32f10x_rtc.c stm32f10x_flash.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_exti.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group User
    ./User/: main.c stm32f10x_it.c
  group Basic
    ./Basic/delay/: delay.c
    ./Basic/sys/: sys.c
    ./Basic/usart/: usart.c
    ./Basic/spi/: spi.c
    ./Basic/i2c/: i2c_hardware.c i2c_software.c
    ./Basic/adc/: adc.c
    ./Basic/pwm/: pwm.c
  group Hardware
    ./Hardware/MPU6050/: MPU6050.c
    ./Hardware/NRF24L01/: nrf24l01.c
    ./Hardware/BMP280/: bmp280.c
    ./Hardware/HMC5883L/: HMC5883L.c
    ./Hardware/BT/: BT.c
    ./Hardware/FBM320/: fbm320.c
    ./Hardware/Motor/: Motor.c
    ./Hardware/MPU6050/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./Hardware/MPU6050/EXTI/: myexti.c
    ./Hardware/DMP/: dmp.c
    ./Control/: control.c
